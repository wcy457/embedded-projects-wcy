# Keil uVision project Car_APP.uvprojx, settings and files
target Car_APP (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Car_APP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE, LV_CONF_INCLUDE_SIMPLE, LV_KCONFIG_IGNORE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\BSP\LCD;..\midware;..;..\BSP\LVGL;..\BSP\Canif;..\BSP\boot;..\BSP\flash
  memory RVCT4: ROM 0x8008000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c rtc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group BSP
    ../BSP/LCD/: lcd.c lcd_font.c
    ../BSP/LVGL/: lv_port_disp.c
    ../BSP/Canif/: canif.c can_handle.c
    ../BSP/boot/: boot_manager.c
    ../BSP/flash/: inter_flashif.c
  group lvgl
    ../midware/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../midware/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../midware/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../midware/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../midware/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../midware/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../midware/lvgl/src/extra/: lv_extra.c
    ../midware/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../midware/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../midware/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../midware/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../midware/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../midware/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../midware/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../midware/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../midware/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../midware/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../midware/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../midware/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../midware/lvgl/src/extra/widgets/led/: lv_led.c
    ../midware/lvgl/src/extra/widgets/list/: lv_list.c
    ../midware/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../midware/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../midware/lvgl/src/extra/widgets/span/: lv_span.c
    ../midware/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../midware/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../midware/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../midware/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../midware/lvgl/src/extra/widgets/win/: lv_win.c
  group ui
    ../midware/ui/: ui.c
    ../midware/ui/images/: ui_img_942215904.c ui_img_1601502596.c ui_img_light_png.c ui_img_safety_belt_png.c ui_img_temp_gray_png.c ui_img_turn_light_png.c
software components: CMSIS:CORE 4.3.0
